# Keil uVision project project.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\user;..\code;..\ml_libs;..\m0_sdk\source;..\m0_sdk\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ..\m0_sdk\source\ti\devices\msp\m0p\linker_files\keil\mspm0g3507.sct
  group user
    ./: main.c startup_mspm0g350x_uvision.s isr.c ti_msp_dl_config.c ti_msp_dl_config.h track.c track.h xunji.c xunji.h encoder.c encoder.h IMU.c IMU.h key.c key.h _pid.c _pid.h
    ../m0_sdk/source/ti/devices/msp/m0p/: mspm0g350x.h
  group driverlib
    ../m0_sdk/source/ti/driverlib/: dl_common.c dl_timer.c dl_uart.c
    ../m0_sdk/source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group ml_libs
    ../ml_libs/: headfile.h ml_gpio.c ml_gpio.h ml_tim.c ml_tim.h ml_uart.c ml_uart.h ml_exti.c ml_exti.h ml_delay.c ml_delay.h ml_system.c ml_system.h ml_pwm.c ml_pwm.h ml_oled.c ml_oled.h ml_oled_font.h ml_motor.c ml_motor.h
